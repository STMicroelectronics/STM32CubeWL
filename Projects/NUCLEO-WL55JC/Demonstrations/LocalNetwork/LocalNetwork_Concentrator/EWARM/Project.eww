<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LocalNetwork_Concentrator.ewp</path>
  </project>
  <batchBuild />
</workspace>
