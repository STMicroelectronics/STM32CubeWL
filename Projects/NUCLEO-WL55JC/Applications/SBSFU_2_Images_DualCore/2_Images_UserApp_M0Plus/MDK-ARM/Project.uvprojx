# Keil uVision project Project.uvprojx, settings and files
target STM32WL55JC_Nucleo_2_Images_UserApp_M0Plus (6120000::V6.12::.\ARMCLANG)
  device: STM32WL55JCIx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UserApp_CM0Plus
  AfterMake: fromelf #L --bincombined --output=$L../../@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . #L @L.bin 1 1
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL55xx,CORE_CM0PLUS,KMS_ENABLED,DISABLE_IMAGE_STATE_HANDLING
  c include: ../Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/CM0PLUS/SBSFU/App;../../2_Images_SBSFU/Common;../../Linker_Common/MDK-ARM;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/iKMS;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L0/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\UserApp_cm0plus.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm0plus.s svc_handler.s
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/User
    ../Src/: com.c common.c flash_if.c fw_update_app.c kms_object_update_app.c main.c mpu.c se_user_code.c stm32wlxx_it.c test_protections.c tkms_app.c tkms_app_derive_key.c tkms_app_encrypt_decrypt.c tkms_app_sign_verify.c ymodem.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_gtzc.c stm32wlxx_hal_iwdg.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wlxx.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/STM32WL55JC_Nucleo_CM0PLUS/Exe/: se_interface_appli.txt
software components: CMSIS:CORE 5.2.0
