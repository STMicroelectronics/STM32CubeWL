# IAR project CM4.ewp, settings and files
configuration CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WL55xx
  ICCARM.CCIncludePath2: ../Common; ../CM4/Inc; ../../2_Images_SECoreBin/Inc; ../../Linker_Common/EWARM; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm4.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User
    ../CM4/Src/: main.c stm32wlxx_hal_msp.c stm32wlxx_it.c sfu_com_loader.c sfu_loader.c sfu_low_level_security.c sfu_new_image.c
  group Application/Common
    ../Common/: sfu_com_trace.c sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/STM32WLxx_LL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_ll_utils.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Source/Templates/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_hsem.c stm32wlxx_hal_iwdg.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c
