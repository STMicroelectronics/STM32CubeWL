<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\KMS_Derive_Key.ewp</path>
  </project>
  <batchBuild />
</workspace>
