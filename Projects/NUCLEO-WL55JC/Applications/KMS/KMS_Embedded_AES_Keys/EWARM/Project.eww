<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\KMS_Embedded_AES_Keys.ewp</path>
  </project>
  <batchBuild />
</workspace>
