# IAR project KMS_Blob_Example.ewp, settings and files
configuration KMS_Blob_Example (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE="..\Inc\mbedtls_config.h"; KMS_ENABLED; CORE_CM4; USE_HAL_DRIVER; STM32WL55xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/ST; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS; ../../../../../../Middlewares/Third_Party/mbed-crypto/include; ../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls; ../../../../../../Middlewares/Third_Party/mbed-crypto/library; ../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KMS_Blob_Example.hex
  ILINK.IlinkOutputFile: KMS_Blob_Example.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User
    ../Src/: app_kms.c ca_low_level.c com.c common.c flash_if.c kms_low_level.c kms_object_update_app.c main.c nvms_low_level.c stm32wlxx_hal_msp.c stm32wlxx_it.c ymodem.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_pka.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Middlewares/KMS
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/: ca_aes.c ca_core.c ca_ecc.c ca_hash.c ca_if_utils.c ca_rng.c ca_rsa.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL/: ca_aes_hal.c ca_ecc_hal.c ca_rsa_hal.c mac_stm32hal.c rsa_stm32hal.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED/: ca_aes_mbed.c ca_ecc_mbed.c ca_hash_mbed.c ca_rng_mbed.c ca_rsa_mbed.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules/: kms_counter.c kms_digest.c kms_dyn_obj.c kms_enc_dec.c kms_key_mgt.c kms_nvm_storage.c kms_sign_verify.c kms_vm_storage.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core/: kms_der_x962.c kms_ecc.c kms_entry.c kms_init.c kms_mem.c kms_objects.c kms_platf_objects.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS/: kms_interface.c tkms.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/include/: CMakeLists.txt
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: platform_util.c sha1.c sha256.c
