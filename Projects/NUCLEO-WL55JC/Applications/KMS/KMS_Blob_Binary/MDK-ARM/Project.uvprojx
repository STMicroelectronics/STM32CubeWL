# Keil uVision project Project.uvprojx, settings and files
target STM32WL55JC_Nucleo_KMS_Blob_Binary (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L..\..\@L.bin
  AfterMake: postbuild.bat .  $L..\..\@L 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL55xx
  c include: ../Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\KMS_Blob.sct
  link misc: --diag_suppress L6305W
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: kms_blob_example_keys.c
software components: CMSIS:CORE 4.3.0
