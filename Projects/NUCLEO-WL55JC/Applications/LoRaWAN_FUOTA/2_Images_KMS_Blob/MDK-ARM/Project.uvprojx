# Keil uVision project Project.uvprojx, settings and files
target STM32WL55JC_Nucleo_2_Images_KMS_Blob (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WL55JCIx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KMS_blob
  AfterMake: fromelf #L --bin --output=$L../../@L.bin
  AfterMake: postbuild.bat .  @L 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL55xx,CORE_CM0PLUS
  c include: ../Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Platform;../../2_Images_SECoreBin/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: KMS_Blob.sct
  link misc: --diag_suppress L6305W
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: kms_blob_example_keys.c
software components: CMSIS:CORE 5.2.0
