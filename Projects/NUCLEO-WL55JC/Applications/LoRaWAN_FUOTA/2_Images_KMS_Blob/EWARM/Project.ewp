# IAR project Project.ewp, settings and files
configuration STM32WL55JC_Nucleo_2_Images_KMS_Blob (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M0+ ST STM32WL55JC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WL55xx; CORE_CM0PLUS
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Platform; ..\..\2_Images_SECoreBin\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\KMS_Blob.bin
  postbuild: cmd /C "cmd /C postbuild.bat "$PROJ_DIR$" "KMS_Blob" 1 "
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: kms_blob_example_keys.c
