# IAR project LoRaWAN_End_Node.ewp, settings and files
configuration LoRaWAN_End_Node (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WL55xx; KMS_ENABLED
  ICCARM.CCIncludePath2: ../Core/Inc; ../LoRaWAN/App; ../LoRaWAN/Target; ../KMS/App; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/timer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ../../1_Image_SECoreBin/Inc; ../../1_Image_BFU/BFU/App; ../../Linker_Common/EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\iKMS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\LoRaWAN_End_Node.bin
  postbuild: cmd /C "cmd /C ..\..\1_Image_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "LoRaWAN_End_Node.bin" 1 1"
  ILINK.IlinkOutputFile: LoRaWAN_End_Node.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm4.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: adc.c adc_if.c dma.c flash_if.c gpio.c main.c rtc.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c subghz.c sys_app.c sys_debug.c sys_sensors.c timer_if.c usart.c usart_if.c
  group Application/User/KMS/App
    ../KMS/App/: app_kms.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: app_lorawan.c CayenneLpp.c fw_update_agent.c lora_app.c lora_info.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: frag_decoder_if.c radio_board_if.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_ll_adc.c
  group Middlewares/LoRaWAN
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: cmac.c lorawan_aes.c soft-se.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages/: FragDecoder.c LmhpClockSync.c LmhpCompliance.c LmhpFirmwareManagement.c LmhpFragmentation.c LmhpPackagesRegistration.c LmhpRemoteMcastSetup.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/: LmHandler.c NvmDataMgmt.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN470A20.c RegionCN470A26.c RegionCN470B20.c RegionCN470B26.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c
  group Middlewares/STM32_Secure_Engine
    ../../1_Image_BFU/EWARM/: se_interface_appli.o
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c radio_fw.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
