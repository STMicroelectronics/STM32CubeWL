# Keil uVision project Sigfox_AT_Slave_DualCore_CM4.uvprojx, settings and files
target Sigfox_AT_Slave_DualCore_CM4 (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20007FFF) IRAM2(0x20008000-0x2000AFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Sigfox_AT_Slave_DualCore_CM4 +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,STM32WL55xx
  c misc: -fshort-enums
  c include: ../CM4/Core/Inc;../CM4/Sigfox/App;../CM4/Sigfox/Target;../CM4/MbMux;../Common/Board;../Common/MbMux;../Common/System;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/Third_Party/Sigfox/Monarch;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x3000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/Core
    ../CM4/Core/Src/: adc.c adc_if.c dma.c ipcc.c ipcc_if.c main.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c sys_app.c timer_if.c usart.c usart_if.c
    ../Common/Board/: board_resources.c
    ../Common/System/: sys_debug.c
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/MbMux
    ../CM4/MbMux/: mbmux.c mbmuxif_kms.c mbmuxif_radio.c mbmuxif_sigfox.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c sigfox_mbwrapper.c system_mbwrapper.c
  group Application/Sigfox/App
    ../CM4/Sigfox/App/: app_sigfox.c sgfx_app.c sgfx_at.c sgfx_command.c sgfx_eeprom_if.c
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_ll_adc.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
