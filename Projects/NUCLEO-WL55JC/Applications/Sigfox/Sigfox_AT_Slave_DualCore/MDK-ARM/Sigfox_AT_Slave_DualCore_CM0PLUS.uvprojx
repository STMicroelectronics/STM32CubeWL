# Keil uVision project Sigfox_AT_Slave_DualCore_CM0PLUS.uvprojx, settings and files
target Sigfox_AT_Slave_DualCore_CM0PLUS (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Sigfox_AT_Slave_DualCore_CM0PLUS +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM0PLUS,KMS_ENABLED,STM32WL55xx,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c misc: -fshort-enums
  c include: ../CM0PLUS/Core/Inc;../CM0PLUS/KMS/App;../CM0PLUS/Sigfox/App;../CM0PLUS/Sigfox/Target;../CM0PLUS/MbMux;../Common/Board;../Common/MbMux;../Common/System;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/Third_Party/Sigfox/Crypto;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/ST;../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls;../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa;../../../../../../Middlewares/Third_Party/Sigfox/Monarch;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x2000c000 size 0x4000
  scatter file: stm32wl55xx_flash_cm0plus.sct
  group Application/Core
    ../Common/Board/: board_resources.c
    ../CM0PLUS/Core/Src/: ca_low_level.c flash_if.c ipcc.c ipcc_if.c kms_low_level.c lptim.c main.c mn_lptim_if.c nvms_low_level.c rtc.c stm32_lpm_if.c stm32wlxx_it.c subghz.c sys_app.c timer_if.c
    ../Common/System/: sys_debug.c
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm0plus.s
  group Application/KMS/App
    ../CM0PLUS/KMS/App/: app_kms.c
  group Application/MbMux
    ../CM0PLUS/MbMux/: features_info.c mbmux.c mbmuxif_kms.c mbmuxif_radio.c mbmuxif_sigfox.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c sigfox_info.c sigfox_mbwrapper.c
  group Application/Sigfox/App
    ../CM0PLUS/Sigfox/App/: app_sigfox.c ee.c sgfx_cstimer.c sgfx_eeprom_if.c
  group Application/Sigfox/Target
    ../CM0PLUS/Sigfox/Target/: mcu_api.c mn_api.c radio_board_if.c rf_api.c se_nvm.c sgfx_credentials.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_lptim.c stm32wlxx_hal_pka.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c
  group Middlewares/KMS
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/: ca_aes.c ca_core.c ca_ecc.c ca_hash.c ca_if_utils.c ca_rng.c ca_rsa.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL/: ca_aes_hal.c ca_ecc_hal.c ca_rsa_hal.c mac_stm32hal.c rsa_stm32hal.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED/: ca_aes_mbed.c ca_ecc_mbed.c ca_hash_mbed.c ca_rng_mbed.c ca_rsa_mbed.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core/: kms_der_x962.c kms_ecc.c kms_entry.c kms_init.c kms_mem.c kms_objects.c kms_platf_objects.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules/: kms_digest.c kms_dyn_obj.c kms_enc_dec.c kms_key_mgt.c kms_nvm_storage.c kms_sign_verify.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS/: kms_interface.c tkms.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: platform_util.c sha1.c sha256.c
  group Middlewares/Sigfox
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest/: SFX_ADDON_RFP_V0.6.0_SE_FDL_MON.a
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib/: SFX_LIB_V2.8.1_SE_FDL_MON.a
    ../../../../../../Middlewares/Third_Party/Sigfox/Crypto/: Sgfx-Cmac-V1.0.0-CM0-O3.a sigfox_aes.c sigfox_data.c
    ../../../../../../Middlewares/Third_Party/Sigfox/Monarch/: Sgfx-Monarch-V2.0.0-CM0-O3.a
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
software components: CMSIS:CORE 5.4.0
