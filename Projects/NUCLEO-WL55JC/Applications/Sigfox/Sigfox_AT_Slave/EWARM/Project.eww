<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Sigfox_AT_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>
