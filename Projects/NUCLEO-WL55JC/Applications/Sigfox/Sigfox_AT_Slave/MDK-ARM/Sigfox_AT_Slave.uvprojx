# Keil uVision project Sigfox_AT_Slave.uvprojx, settings and files
target Sigfox_AT_Slave (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: IROM(0x08000000-0x801FFFF) IROM2(0x0803F800-0x803FFFF) IRAM(0x20000000-0x20007FFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Sigfox_AT_Slave +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WL55xx,CORE_CM4,USE_HAL_DRIVER
  c misc: -fshort-enums
  c include: ../Core/Inc;../Sigfox/App;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/Third_Party/Sigfox/Crypto;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest;../../../../../../Middlewares/Third_Party/Sigfox/Monarch;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/trace/adv_trace;../Sigfox/Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3e000
  memory RVCT5: ROM 0x803e500 size 0x300
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/App
    ../Sigfox/App/: app_sigfox.c ee.c sgfx_app.c sgfx_at.c sgfx_command.c sgfx_cstimer.c sgfx_eeprom_if.c
    ../Core/Src/: sys_app.c sys_debug.c
  group Application/Core
    ../Core/Src/: adc.c adc_if.c board_resources.c dma.c flash_if.c lptim.c main.c mn_lptim_if.c rtc.c timer_if.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c subghz.c usart.c usart_if.c
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/Target
    ../Sigfox/Target/: mcu_api.c mn_api.c radio_board_if.c rf_api.c se_nvm.c sgfx_credentials.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_lptim.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Middlewares/Sigfox
    ../../../../../../Middlewares/Third_Party/Sigfox/Crypto/: sigfox_aes.c Sgfx-Cmac-V1.0.0-CM0-O3.a sigfox_data.c
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest/: SFX_ADDON_RFP_V0.6.0_SE_FDL_MON.a
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib/: SFX_LIB_V2.8.1_SE_FDL_MON.a
    ../../../../../../Middlewares/Third_Party/Sigfox/Monarch/: Sgfx-Monarch-V2.0.0-CM0-O3.a
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
software components: CMSIS:CORE 4.3.0
