<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LoRaWAN_End_Node_FreeRTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
