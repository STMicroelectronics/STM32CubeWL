# Keil uVision project LoRaWAN_End_Node_FreeRTOS.uvprojx, settings and files
target LoRaWAN_End_Node_FreeRTOS (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20008000-0x2000BFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: LoRaWAN_End_Node_FreeRTOS +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL55xx
  c misc: -fshort-enums
  c include: ../Core/Inc;  ../LoRaWAN/App;  ../LoRaWAN/Target;  ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;  ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;  ../../../../../../Utilities/trace/adv_trace;  ../../../../../../Utilities/misc;  ../../../../../../Utilities/timer;  ../../../../../../Utilities/lpm/tiny_lpm;  ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;  ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;  ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3;  ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages;  ../../../../../../Middlewares/Third_Party/SubGHz_Phy;  ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;  ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;  ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto;  ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region;  ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac;  ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler;  ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities;  ../../../../../../Drivers/CMSIS/Include;  ../../../../../../Drivers/BSP/STM32WLxx_Nucleo
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c app_freertos.c adc.c dma.c gpio.c stm32_lpm_if.c sys_app.c sys_debug.c sys_sensors.c timer_if.c adc_if.c usart_if.c rtc.c subghz.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c flash_if.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: radio_board_if.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c lora_info.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group Middlewares/LoRaWAN
    ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages/: LmhpCompliance.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: cmac.c lorawan_aes.c soft-se.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN470A20.c RegionCN470A26.c RegionCN470B20.c RegionCN470B26.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/: LmHandler.c NvmDataMgmt.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio_driver.c radio_fw.c radio.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
