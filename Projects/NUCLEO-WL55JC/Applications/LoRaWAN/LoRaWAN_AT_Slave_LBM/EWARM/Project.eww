<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LoRaWAN_AT_Slave_LBM.ewp</path>
  </project>
  <batchBuild />
</workspace>
