<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FreeRTOS_HSEM_DualCore_CM0PLUS.ewp</path>
  </project><project>
    <path>$WS_DIR$\FreeRTOS_HSEM_DualCore_CM4.ewp</path>
  </project>
  <batchBuild />
</workspace>
