# IAR project Project.ewp, settings and files
configuration STM32WL55JC_Nucleo_1_Image_BFU (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WL55xx; KMS_ENABLED; DISABLE_IMAGE_STATE_HANDLING
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ..\Core\Inc; ..\BFU\App; ..\BFU\Target; ..\..\1_Image_SECoreBin\Inc; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Interface; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\iKMS; ..\..\..\..\..\..\Drivers\BSP\STM32WLxx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "$PROJ_DIR$.\se_interface_appli.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: SE_CORE_Bin
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm4.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/Core
    ../Core/Src/: main.c stm32wlxx_hal_msp.c stm32wlxx_it.c
  group Application/BFU/App
    ../BFU/App/: sfu_loader.c sfu_boot.c sfu_com_loader.c sfu_com_trace.c sfu_error.c sfu_test.c sfu_fwimg_common.c sfu_new_image.c sfu_kms.c sfu_interface_crypto_scheme.c
  group Application/BFU/Target
    ../BFU/Target/: sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level_security.c
  group Application/EWARM
    ./: startup_stm32wl55xx_cm4.s
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_iwdg.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c
  group Drivers/STM32WLxx_LL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_ll_utils.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Source/Templates/: system_stm32wlxx.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c
  group Middlewares/STM32_Key_Management_Services
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/iKMS/: se_interface_kms.c
