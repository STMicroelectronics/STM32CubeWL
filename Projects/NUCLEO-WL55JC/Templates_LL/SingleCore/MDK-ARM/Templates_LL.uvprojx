# Keil uVision project Templates_LL.uvprojx, settings and files
target Templates_LL (6120000::V6.12::.\ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Templates_LL +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WL55xx,CORE_CM4,USE_FULL_LL_DRIVER,HSE_VALUE=32000000
  c include: ../Inc; ../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../Drivers/CMSIS/Include;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wl55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wlxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_ll_utils.c stm32wlxx_ll_exti.c stm32wlxx_ll_pwr.c stm32wlxx_ll_gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32wlxx.c
software components: CMSIS:CORE 5.2.0
