# Keil uVision project IPCC_SimplexMode_DualCore_CM4.uvprojx, settings and files
target IPCC_SimplexMode_DualCore_CM4 (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: IPCC_SimplexMode_DualCore_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,STM32WL55xx,USE_FULL_LL_DRIVER,HSE_VALUE=32000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c misc: -Wno-format
  c include: ../CM4/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32wlxx_it.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_ll_utils.c stm32wlxx_ll_exti.c stm32wlxx_ll_gpio.c stm32wlxx_ll_pwr.c stm32wlxx_ll_rcc.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
