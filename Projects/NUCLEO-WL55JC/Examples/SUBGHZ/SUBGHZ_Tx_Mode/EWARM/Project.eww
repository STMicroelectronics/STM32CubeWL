<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SUBGHZ_Tx_Mode.ewp</path>
  </project>
  <batchBuild />
</workspace>
