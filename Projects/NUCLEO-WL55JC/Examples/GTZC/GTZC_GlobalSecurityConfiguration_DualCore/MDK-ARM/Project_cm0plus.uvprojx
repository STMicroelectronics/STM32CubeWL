# Keil uVision project Project_cm0plus.uvprojx, settings and files
target NUCLEO-WL55JC_GTZC_GlobalSecurityConfiguration_DualCore (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WL55JCIx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GTZC_GlobalSecurityConfiguration_DualCore +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL55xx,CORE_CM0PLUS
  c include: ../CM0PLUS/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x2000c000 size 0x4000
  scatter file: .\stm32wl55xx_flash_dualcore.sct
  link misc: --predefine=-DCPU2
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm0plus.s
  group Application/User
    ../CM0PLUS/Src/: main.c stm32wlxx_hal_msp.c stm32wlxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_gtzc.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c
software components: CMSIS:CORE 5.3.0
