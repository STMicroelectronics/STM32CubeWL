# Keil uVision project Templates_LL_CM0PLUS.uvprojx, settings and files
target Templates_LL_CM0PLUS (6180000::V6.18::ARMCLANG)
  device: STM32WL5MOCHx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Templates_LL_CM0PLUS +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM0PLUS,STM32WL55xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c misc: -Wno-macro-redefined
  c include: ../CM0PLUS/Inc;../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x2000c000 size 0x4000
  scatter file: stm32wl5mxx_flash_cm0plus.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32wl5mxx_cm0plus.s
  group Application/User/CM0PLUS
    ../CM0PLUS/Src/: main.c stm32wlxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_ll_exti.c stm32wlxx_ll_gpio.c stm32wlxx_ll_pwr.c stm32wlxx_ll_rcc.c stm32wlxx_ll_utils.c
