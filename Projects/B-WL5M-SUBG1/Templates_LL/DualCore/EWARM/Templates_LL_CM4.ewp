# IAR project Templates_LL_CM4.ewp, settings and files
configuration Templates_LL_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL5MOC_M4 ST STM32WL5MOC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; STM32WL55xx; USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=48000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=0; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1
  ICCARM.CCIncludePath2: ../CM4/Inc; ../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templates_LL_CM4.hex
  ILINK.IlinkOutputFile: Templates_LL_CM4.out
  ILINK.IlinkIcfFile: stm32wl5mxx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32wlxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_ll_exti.c stm32wlxx_ll_gpio.c stm32wlxx_ll_pwr.c stm32wlxx_ll_rcc.c stm32wlxx_ll_utils.c
