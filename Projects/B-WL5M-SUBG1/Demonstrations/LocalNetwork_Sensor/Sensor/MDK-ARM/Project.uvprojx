# Keil uVision project Project.uvprojx, settings and files
target Demo_Sensor (6160000::V6.16::ARMCLANG)
  device: STM32WL5MOCHx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IROM(0x08000000-0x803FFFF) IRAM(0x20000000-0x20007FFF) IRAM2(0x20008000-0x2000BFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: Demo_Sensor +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WL5Mxx,CORE_CM4,USE_HAL_DRIVER
  c include: ../SubGHz_Phy/App;../SubGHz_Phy/Target;../Core/Inc;../../../../../NUCLEO-WL55JC/Demonstrations/LocalNetwork/LocalNetwork_Concentrator/Common/Inc;../../../../../../Drivers/BSP/B-WL5M-SUBG;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../../Drivers/BSP/Components/mx25l4006;../../../../../../Drivers/BSP/Components/iis2mdc;../../../../../../Drivers/BSP/Components/ilps22qs;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/radio_driver;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/trace/adv_trace;../Middlewares/ST/STM32_MotionAR_Library/Inc;../Middlewares/ST/STM32_MotionEC_Library/Inc;../Middlewares/ST/STM32_MotionMC_Library/Inc;../Middlewares/ST/STM32_MotionPM_Library/Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x4000
  scatter file: .\stm32wl5mxx_flash_cm4.sct
  link misc: ../Middlewares/ST/STM32_MotionAR_Library/Lib/MotionAR_CM3_wc16_ot.a
../Middlewares/ST/STM32_MotionEC_Library/Lib/MotionEC_CM3_wc16_ot.a
../Middlewares/ST/STM32_MotionMC_Library/Lib/MotionMC_CM3_wc16_ot.a
../Middlewares/ST/STM32_MotionPM_Library/Lib/MotionPM_CM3_wc16_ot.a
  group Application/App
    ../../../../../NUCLEO-WL55JC/Demonstrations/LocalNetwork/LocalNetwork_Concentrator/Common/Src/: demo_radio_utils.c demo_regions.c demo_utils.c
    ../SubGHz_Phy/App/: demo_sensor.c meters.c
  group Application/Core
    ../Core/Src/: adc.c adc_if.c dma.c gpio.c main.c rtc.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c subghz.c sys_app.c sys_debug.c timer_if.c usart.c usart_if.c
  group Application/MDK-ARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/Target
    ../SubGHz_Phy/Target/: radio_board_if.c
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg.c b_wl5m_subg_bus.c b_wl5m_subg_env_sensors.c b_wl5m_subg_env_sensors_ex.c b_wl5m_subg_motion_sensors.c b_wl5m_subg_motion_sensors_ex.c b_wl5m_subg_radio.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_lptim.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/radio_driver/: radio.c radio_driver.c radio_fw.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
software components: CMSIS:CORE 4.3.0
