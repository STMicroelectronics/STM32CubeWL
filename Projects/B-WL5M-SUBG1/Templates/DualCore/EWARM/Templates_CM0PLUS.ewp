# IAR project Templates_CM0PLUS.ewp, settings and files
configuration Templates_CM0PLUS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL5MOC_M0+ ST STM32WL5MOC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM0PLUS; STM32WL5Mxx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../CM0PLUS/Inc; ../../../../../Drivers/BSP/B-WL5M-SUBG; ../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templates_CM0PLUS.hex
  ILINK.IlinkOutputFile: Templates_CM0PLUS.out
  ILINK.IlinkIcfFile: stm32wl5mxx_flash_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl5mxx_cm0plus.s
  group Application/User/CM0PLUS
    ../CM0PLUS/Src/: main.c stm32wlxx_hal_msp.c stm32wlxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c
