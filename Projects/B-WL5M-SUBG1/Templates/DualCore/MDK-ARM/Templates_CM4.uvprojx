# Keil uVision project Templates_CM4.uvprojx, settings and files
target Templates_CM4 (6180000::V6.18::ARMCLANG)
  device: STM32WL5MOCHx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Templates_CM4 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL5Mxx
  c include: ../CM4/Inc;../../../../../Drivers/BSP/B-WL5M-SUBG;../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20008000 size 0x4000
  scatter file: stm32wl5mxx_flash_cm4.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32wlxx_hal_msp.c stm32wlxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c
