# IAR project Project.ewp, settings and files
configuration B-WL5M-SUBG1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL5MOC_M4 ST STM32WL5MOC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32WL5Mxx; USE_HAL_DRIVER; B_WL5M_SUBG; CORE_CM4; ARM_MATH_CM4; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WLxx\Include; ..\..\..\..\..\..\Drivers\STM32WLxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\B-WL5M-SUBG; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\stts22h; ..\..\..\..\..\..\Drivers\BSP\Components\ilps22qs; ..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\..\..\..\Drivers\BSP\Components\mx25l4006
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BSP.hex
  ILINK.IlinkOutputFile: b_wl5m_subg.out
  ILINK.IlinkIcfFile: stm32wl5mxx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg.c b_wl5m_subg_bus.c b_wl5m_subg_eeprom.c b_wl5m_subg_env_sensors.c b_wl5m_subg_env_sensors_ex.c b_wl5m_subg_flash.c b_wl5m_subg_motion_sensors.c b_wl5m_subg_motion_sensors_ex.c b_wl5m_subg_radio.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/mx25l4006/: mx25l4006.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32wl5mxx_cm4.s
  group Example/User
    ../Src/: eeprom.c flash.c led.c main.c radio.c sensors.c stm32wlxx_hal_msp.c stm32wlxx_it.c
