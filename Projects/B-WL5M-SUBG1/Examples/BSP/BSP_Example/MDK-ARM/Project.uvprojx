# Keil uVision project Project.uvprojx, settings and files
target B-WL5M-SUBG1 (6180000::V6.18::ARMCLANG)
  device: STM32WL5MOCHx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: b_wl5m_subg +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WL5Mxx,USE_HAL_DRIVER,B_WL5M_SUBG ,CORE_CM4,ARM_MATH_CM4,USE_USB_FS,__DBG_ITM
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-WL5M-SUBG;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/Components/ilps22qs;../../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../../Drivers/BSP/Components/iis2mdc;../../../../../../Drivers/BSP/Components/mx25l4006
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: stm32wl5mxx_flash_cm4.sct
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg.c b_wl5m_subg_bus.c b_wl5m_subg_eeprom.c b_wl5m_subg_env_sensors.c b_wl5m_subg_env_sensors_ex.c b_wl5m_subg_flash.c b_wl5m_subg_motion_sensors.c b_wl5m_subg_motion_sensors_ex.c b_wl5m_subg_radio.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/mx25l4006/: mx25l4006.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32wl5mxx_cm4.s
  group Example/User
    ../Src/: eeprom.c flash.c led.c main.c radio.c sensors.c stm32wlxx_hal_msp.c stm32wlxx_it.c
    ./: Serial.c Retarget.c
