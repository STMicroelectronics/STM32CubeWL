# IAR project LoRaWAN_End_Node_DualCore_CM4.ewp, settings and files
configuration LoRaWAN_End_Node_DualCore_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL5MOC_M4 ST STM32WL5MOC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WL5Mxx
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../CM4/LoRaWAN/App; ../CM4/LoRaWAN/Target; ../CM4/MbMux; ../Common/Board; ../Common/System; ../Common/MbMux; ../../../../../../Drivers/BSP/B-WL5M-SUBG; ../../../../../../Drivers/BSP/Components/mx25l4006; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/timer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Drivers/CMSIS/Include; ../../Linker_Common/EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\LoRaWAN_End_Node_DualCore_CM4.bin
  postbuild: cmd /C "cmd /C ..\..\2_Images_SECoreBin\EWARM\postbuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "LoRaWAN_End_Node_DualCore_CM4.bin" 2 1"
  ILINK.IlinkOutputFile: LoRaWAN_End_Node_DualCore_CM4.out
  ILINK.IlinkIcfFile: stm32wl5mxx_flash_cm4.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: adc.c adc_if.c dma.c flash_if.c gpio.c ipcc.c ipcc_if.c main.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c sys_app.c sys_sensors.c timer_if.c usart.c usart_if.c
  group Application/User/CM4/LoRaWAN/App
    ../CM4/LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c
  group Application/User/CM4/MbMux
    ../CM4/MbMux/: LmHandler_mbwrapper.c mbmux.c mbmuxif_flash.c mbmuxif_lora.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg_flash.c
    ../../../../../../Drivers/BSP/Components/mx25l4006/: mx25l4006.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_ll_adc.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
