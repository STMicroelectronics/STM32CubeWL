# Keil uVision project LoRaWAN_End_Node_DualCore_CM4.uvprojx, settings and files
target LoRaWAN_End_Node_DualCore_CM4 (6160000::V6.16::ARMCLANG)
  device: STM32WL5MOCHx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: LoRaWAN_End_Node_DualCore_CM4 +hex
  AfterMake: fromelf #L --bincombined --output=$L../@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . #L @L.bin 2 1
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL5Mxx
  c misc: -fshort-enums
  c include: ../CM4/Core/Inc;../CM4/LoRaWAN/App;../CM4/LoRaWAN/Target;../CM4/MbMux;../Common/Board;../Common/System;../Common/MbMux;../../../../../../Drivers/BSP/B-WL5M-SUBG;../../../../../../Drivers/BSP/Components/mx25l4006;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region;../../../../../../Middlewares/Third_Party/LoRaWAN/Mac;../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler;../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: stm32wl5mxx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Application/User/CM4/LoRaWAN/App
    ../CM4/LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c adc.c dma.c gpio.c ipcc.c ipcc_if.c stm32_lpm_if.c sys_app.c sys_sensors.c adc_if.c timer_if.c usart_if.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c flash_if.c
  group Application/User/CM4/MbMux
    ../CM4/MbMux/: LmHandler_mbwrapper.c mbmux.c mbmuxif_flash.c mbmuxif_lora.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg_flash.c
    ../../../../../../Drivers/BSP/Components/mx25l4006/: mx25l4006.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 5.6.0
