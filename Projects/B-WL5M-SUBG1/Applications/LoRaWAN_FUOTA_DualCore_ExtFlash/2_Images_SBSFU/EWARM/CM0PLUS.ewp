# IAR project CM0PLUS.ewp, settings and files
configuration CM0PLUS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL5MOC_M0+ ST STM32WL5MOC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WL5Mxx; CORE_CM0PLUS; KMS_ENABLED
  ICCARM.CCIncludePath2: ../Common; ../CM0PLUS/Core/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/B-WL5M-SUBG; ../../../../../../Drivers/BSP/Components/mx25l4006; ..\CM0PLUS\Core\Inc; ..\CM0PLUS\SBSFU\App; ..\CM0PLUS\SBSFU\Target; ..\..\2_Images_SECoreBin\Inc; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Interface; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\iKMS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  postbuild: "$TOOLKIT_DIR$\bin\isymexport.exe" --edit "steering_file.txt" "$TARGET_PATH$" "se_interface_appli.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: SE_CORE_Bin
  ILINK.IlinkIcfFile: stm32wl5mxx_flash_cm0plus.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../CM0PLUS/Core/Src/: main.c stm32wlxx_hal_msp.c stm32wlxx_it.c
  group Application/EWARM
    ./: sfu_se_mpu.s startup_stm32wl5mxx_cm0plus.s
  group Application/SBSFU/App
    ../CM0PLUS/SBSFU/App/: sfu_boot.c sfu_error.c sfu_fwimg_common.c sfu_fwimg_no_swap.c sfu_fwimg_swap.c sfu_interface_crypto_scheme.c sfu_kms.c sfu_mpu_isolation.c sfu_test.c
  group Application/SBSFU/Common
    ../Common/: sfu_com_trace.c sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_ext.c sfu_low_level_flash_int.c
  group Application/SBSFU/Target
    ../CM0PLUS/SBSFU/Target/: sfu_low_level_security.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg.c b_wl5m_subg_flash.c
    ../../../../../../Drivers/BSP/Components/mx25l4006/: mx25l4006.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Source/Templates/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_gtzc.c stm32wlxx_hal_iwdg.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_spi_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Middlewares/STM32_Key_Management_Services
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/iKMS/: se_interface_kms.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c
