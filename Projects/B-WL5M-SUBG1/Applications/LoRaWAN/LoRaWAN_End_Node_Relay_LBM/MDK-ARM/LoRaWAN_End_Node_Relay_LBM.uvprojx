# Keil uVision project LoRaWAN_End_Node_Relay_LBM.uvprojx, settings and files
target LoRaWAN_End_Node_Relay_LBM (6220000::V6.22::ARMCLANG)
  device: STM32WL5MOCHx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: LoRaWAN_End_Node_Relay_LBM +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL5Mxx,NUMBER_OF_STACKS=1,SX126X,ENDNODE,ENDNODE_RELAY
  c misc: -fshort-enums
  c include: ../Core/Inc;../LoRaWAN/App;../LoRaWAN/Target;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_C;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/service_template;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/relay_service;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/lfu_service;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/store_and_forward;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_api;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_manager;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_hal;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/smtc_secure_element;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_supervisor;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_utilities;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_api;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core;../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan;../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src;../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ralf/src;../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ral/src;../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_planner/src;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\smtc_modem_core\lr1mac\src\relay\relay_tx;../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/common;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/B-WL5M-SUBG;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/Components/ilps22qs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wl5mxx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c flash_if.c stm32_lpm_if.c sys_app.c sys_debug.c sys_sensors.c timer_if.c adc_if.c usart_if.c rtc.c rng.c subghz.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: radio_board_if.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg_env_sensors.c b_wl5m_subg_bus.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_rng.c stm32wlxx_hal_rng_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/LoRaWAN/smtc_modem_core
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/: smtc_modem.c smtc_modem_test.c
  group Middlewares/LoRaWAN/smtc_modem_core/lorawan_api
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_api/: lorawan_api.c
  group Middlewares/LoRaWAN/smtc_modem_core/lorawan_manager
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_manager/: lorawan_cid_request_management.c lorawan_class_b_management.c lorawan_dwn_ack_management.c lorawan_join_management.c lorawan_send_management.c
  group Middlewares/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification/: lorawan_certification.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b/: smtc_beacon_sniff.c smtc_ping_slot.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/relay/common
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/common/: relay_mac_parser.c relay_real.c wake_on_radio.c wake_on_radio_ral.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_rx
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_rx/: relay_rx.c relay_rx_mac_parser.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_tx
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_tx/: relay_tx.c relay_tx_mac_parser.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/services
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c smtc_lora_cad_bt.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/services/smtc_multicast
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services/smtc_multicast/: smtc_multicast.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src/: region_as_923.c region_au_915.c region_cn_470.c region_cn_470_rp_1_0.c region_eu_868.c region_in_865.c region_kr_920.c region_ru_864.c region_us_915.c region_ww2g4.c smtc_real.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/beacon_tx_service
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/beacon_tx_service/: lorawan_beacon_tx_service_example.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/lfu_service
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/lfu_service/: file_upload.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/relay_service
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/relay_service/: lorawan_relay_rx_service.c lorawan_relay_tx_service.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/service_template
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/service_template/: service_template.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/store_and_forward
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/store_and_forward/: store_and_forward.c store_and_forward_flash.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_supervisor
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_supervisor/: modem_supervisor_light.c modem_tx_protocol_manager.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_utilities/: circularfs.c fifo_ctrl.c modem_core.c modem_event_utilities.c
  group Middlewares/LoRaWAN/smtc_modem_core/smtc_modem_crypto
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
  group Middlewares/LoRaWAN/smtc_modem_core/smtc_modem_crypto/soft_secure_element
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/soft_secure_element/: aes.c cmac.c soft_se.c
  group Middlewares/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src/: sx126x.c sx126x_driver_version.c
  group Middlewares/SubGHz_Phy/lorawan/radio_planner/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_planner/src/: radio_planner.c
  group Middlewares/SubGHz_Phy/lorawan/smtc_ral/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ral/src/: ral_sx126x.c
  group Middlewares/SubGHz_Phy/lorawan/smtc_ralf/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ralf/src/: ralf_sx126x.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
