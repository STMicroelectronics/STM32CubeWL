# Keil uVision project Sigfox_PushButton_DualCore_CM4.uvprojx, settings and files
target Sigfox_PushButton_DualCore_CM4 (6220000::V6.22::ARMCLANG)
  device: STM32WL5MOCHx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: Sigfox_PushButton_DualCore_CM4 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL5Mxx
  c misc: -fshort-enums
  c include: ../CM4/Core/Inc;../CM4/Sigfox/App;../CM4/Sigfox/Target;../CM4/MbMux;../Common/System;../Common/MbMux;../../../../../../Drivers/BSP/B-WL5M-SUBG;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/Components/ilps22qs;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/Third_Party/Sigfox/Monarch;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest;../../../../../../Middlewares/Third_Party/SubGHz_Phy;..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\radio_driver;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wl5mxx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Application/User/CM4/Sigfox/App
    ../CM4/Sigfox/App/: app_sigfox.c sgfx_app.c sgfx_eeprom_if.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c gpio.c adc.c dma.c ipcc.c usart.c ipcc_if.c stm32_lpm_if.c sys_app.c sys_sensors.c timer_if.c adc_if.c usart_if.c stm32wlxx_it.c stm32wlxx_hal_msp.c flash_if.c
  group Application/User/CM4/MbMux
    ../CM4/MbMux/: mbmux.c mbmuxif_sigfox.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c sigfox_mbwrapper.c system_mbwrapper.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg_env_sensors.c b_wl5m_subg_bus.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
