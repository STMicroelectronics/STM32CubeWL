# IAR project Sigfox_PushButton_DualCore_CM4.ewp, settings and files
configuration Sigfox_PushButton_DualCore_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL5MOC_M4 ST STM32WL5MOC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WL5Mxx
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../CM4/Sigfox/App; ../CM4/Sigfox/Target; ../CM4/MbMux; ../Common/System; ../Common/MbMux; ../../../../../../Drivers/BSP/B-WL5M-SUBG; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/stts22h; ../../../../../../Drivers/BSP/Components/ilps22qs; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/timer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Middlewares/Third_Party/Sigfox/Monarch; ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib; ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/radio_driver; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sigfox_PushButton_DualCore_CM4.hex
  ILINK.IlinkOutputFile: Sigfox_PushButton_DualCore_CM4.out
  ILINK.IlinkIcfFile: stm32wl5mxx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl5mxx_cm4.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: adc.c adc_if.c dma.c flash_if.c gpio.c ipcc.c ipcc_if.c main.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c sys_app.c sys_sensors.c timer_if.c usart.c usart_if.c
  group Application/User/CM4/MbMux
    ../CM4/MbMux/: mbmux.c mbmuxif_radio.c mbmuxif_sigfox.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c sigfox_mbwrapper.c system_mbwrapper.c
  group Application/User/CM4/Sigfox/App
    ../CM4/Sigfox/App/: app_sigfox.c sgfx_app.c sgfx_eeprom_if.c
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WL5M-SUBG
    ../../../../../../Drivers/BSP/B-WL5M-SUBG/: b_wl5m_subg_bus.c b_wl5m_subg_env_sensors.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_ll_adc.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
