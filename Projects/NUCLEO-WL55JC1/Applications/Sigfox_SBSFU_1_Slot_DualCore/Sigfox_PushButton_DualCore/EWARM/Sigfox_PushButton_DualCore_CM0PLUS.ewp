# IAR project Sigfox_PushButton_DualCore_CM0PLUS.ewp, settings and files
configuration Sigfox_PushButton_DualCore_CM0PLUS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M0+ ST STM32WL55JC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM0PLUS; KMS_ENABLED; USE_HAL_DRIVER; STM32WL55xx; CMSIS_NVIC_VIRTUAL
  ICCARM.CCIncludePath2: ../CM0PLUS/Core/Inc; ../CM0PLUS/KMS/App; ../CM0PLUS/Sigfox/App; ../CM0PLUS/Sigfox/Target; ../CM0PLUS/MbMux; ../Common/Board; ../Common/System; ../Common/MbMux; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/timer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/Third_Party/Sigfox/Crypto; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/iKMS; ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core; ../../../../../../Middlewares/Third_Party/Sigfox/Monarch; ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib; ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest; ../../../../../../Drivers/CMSIS/Include; ..\..\Linker_Common\EWARM; ..\..\2_Images_SECoreBin\Inc; ..\..\2_Images_SBSFU\Common; ..\..\2_Images_SBSFU\CM0PLUS\SBSFU\App
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Sigfox_PushButton_DualCore_CM0PLUS.bin
  postbuild: cmd /C "cmd /C ..\..\2_Images_SECoreBin\EWARM\postbuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "Sigfox_PushButton_DualCore_CM0PLUS.bin" 1 1"
  ILINK.IlinkOutputFile: Sigfox_PushButton_DualCore_CM0PLUS.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm0plus.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm0plus.s svc_handler.s
  group Application/User/CM0PLUS/Core
    ../CM0PLUS/Core/Src/: flash_if.c gpio.c ipcc.c ipcc_if.c lptim.c main.c mn_lptim_if.c rtc.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c subghz.c sys_app.c sys_privileged_services.c sys_privileged_wrap.c timer_if.c
  group Application/User/CM0PLUS/KMS/App
    ../CM0PLUS/KMS/App/: app_kms.c
  group Application/User/CM0PLUS/MbMux
    ../CM0PLUS/MbMux/: features_info.c mbmux.c mbmuxif_radio.c mbmuxif_sigfox.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c sigfox_info.c sigfox_mbwrapper.c
  group Application/User/CM0PLUS/Sigfox/App
    ../CM0PLUS/Sigfox/App/: app_sigfox.c ee.c sgfx_cstimer.c sgfx_eeprom_if.c
  group Application/User/CM0PLUS/Sigfox/Target
    ../CM0PLUS/Sigfox/Target/: mcu_api.c mn_api.c radio_board_if.c rf_api.c se_nvm.c sgfx_credentials.c
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_gtzc.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_lptim.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/EWARM/: se_interface_appli.o
  group Middlewares/Sigfox
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest/: SFX_ADDON_RFP_V0.8.0_SE_FDL_MON_ASYNC.a
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib/: SFX_LIB_V2.10.0_SE_FDL_MON.a
    ../../../../../../Middlewares/Third_Party/Sigfox/Crypto/: Sgfx-Cmac-V1.0.0-CM0-O3.a sigfox_aes.c sigfox_data.c
    ../../../../../../Middlewares/Third_Party/Sigfox/Monarch/: Sgfx-Monarch-V2.0.1-CM0-O3.a
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c radio_fw.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
